# Keil uVision project 房间1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 房间1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 沿墙走.c I2C.c I2C.H
